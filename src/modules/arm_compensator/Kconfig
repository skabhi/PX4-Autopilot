## src/modules/arm_compensator/Kconfig
```kconfig
menuconfig MODULES_ARM_COMPENSATOR
	bool "arm_compensator"
	default y
	---help---
		Enable support for ArmCompensator
```
